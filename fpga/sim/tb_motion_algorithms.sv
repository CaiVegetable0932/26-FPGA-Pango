`timescale 1ns/1ps
// Numerical/identity tests use independently computed float reference values.
// No vendor primitive or physical timing/calibration conclusion is implied.
module tb_motion_algorithms;
 reg clk=0;always #5 clk=~clk;reg rst_n=0;
 reg req=0;wire ready,pv;reg [1023:0] cal=0;reg [767:0] pose=0;reg [191:0] manual=0;
 wire [191:0] pm;wire [3:0] ps;wire [63:0] pe,pf;
 pose_affine_model p(.clk(clk),.rst_n(rst_n),.clear(1'b0),.request_valid(req),.request_ready(ready),
  .affine_enable(1'b1),.calibration(cal),.manual_matrix(manual),.epoch(64'd7),.frame_id(64'd99),
  .pose(pose),.pose_status(3'd0),.time_error_us(32'd100),.result_valid(pv),.result_ready(1'b1),
  .result_epoch(pe),.result_frame(pf),.matrix(pm),.status(ps),.calibration_id());
 reg cr=0,en=1;wire cready,cv,overflow;reg [191:0] m=0;wire [191:0] cm;
 affine_dynamic_compose #(.WIDTH(101),.HEIGHT(51)) c(.clk(clk),.rst_n(rst_n),.request_valid(cr),.request_ready(cready),
  .enabled(en),.manual_matrix(m),.zoom_q16(32'd131072),.epoch(64'd7),.frame_id(64'd99),
  .result_valid(cv),.result_ready(1'b1),.matrix(cm),.result_epoch(),.result_frame(),.overflow(overflow));
 integer n;integer expected[0:5];integer error;integer reference_words[0:5],pitch_words[0:5],yaw_words[0:5];
 initial begin
  #21;rst_n=1;
  cal[7:0]=1;cal[63:32]=1;cal[128+:32]=-2000;cal[160+:32]=2000;cal[192+:32]=-2000;cal[224+:32]=2000;
  cal[256+:32]=65536;cal[288+:32]=1000;cal[320+:32]=1;cal[352+:32]=9;cal[576+2*32+:32]=67108864;
  pose[416+:32]=1000;pose[96+:32]=9;manual[64+:32]=123456;
  @(negedge clk);req=1;@(negedge clk);req=0;wait(pv);#1;
  if(ps!=0 || pe!=7 || pf!=99 || $signed(pm[64+:32])<1171269 || $signed(pm[64+:32])>1171273)$fatal(1,"pose radians/model mismatch status=%d value=%d",ps,$signed(pm[64+:32]));
  wait(ready);@(negedge clk);pose[416+:32]=3000;req=1;@(negedge clk);req=0;wait(pv);#1;
  if(ps!=4 || pm!=manual)$fatal(1,"pose out-of-domain did not fall back");
  // Independent float64 evaluation of quantized calibration words at +1.5/-0.75
  // mechanical degrees exercises BOTH Jacobians, negative coefficients and all
  // six outputs. Values are not generated by the RTL's fixed-point arithmetic.
  reference_words[0]=67109;reference_words[1]=13422;reference_words[2]=-63753421;reference_words[3]=-6711;reference_words[4]=80531;reference_words[5]=-35567698;
  pitch_words[0]=671;pitch_words[1]=-1342;pitch_words[2]=6710886;pitch_words[3]=2013;pitch_words[4]=671;pitch_words[5]=-4697620;
  yaw_words[0]=-1342;yaw_words[1]=2013;yaw_words[2]=-3355443;yaw_words[3]=671;yaw_words[4]=-1342;yaw_words[5]=8053064;
  expected[0]=67144;expected[1]=13361;expected[2]=-63533808;expected[3]=-6667;expected[4]=80566;expected[5]=-35796096;
  wait(ready);@(negedge clk);
  for(n=0;n<6;n=n+1)begin cal[384+n*32+:32]=reference_words[n];cal[576+n*32+:32]=pitch_words[n];cal[768+n*32+:32]=yaw_words[n];end
  pose[416+:32]=1500;pose[448+:32]=-750;req=1;@(negedge clk);req=0;wait(pv);#1;
  if(ps!=0)$fatal(1,"dual-axis pose rejected");
  for(n=0;n<6;n=n+1)begin error=$signed(pm[n*32+:32])-expected[n];if(error< -2 || error>2)$fatal(1,"pose coefficient %d error %d",n,error);end
  m[0+:32]=0;m[32+:32]=-671089;m[64+:32]=33554432;m[96+:32]=1342177;m[128+:32]=0;m[160+:32]=-26843546;
  // Independent centred 2x viewport: source x=.5*u+25, y=.5*v+12.5.
  expected[0]=0;expected[1]=-335544;expected[2]=25165820;expected[3]=671089;expected[4]=0;expected[5]=6710879;
  @(negedge clk);cr=1;@(negedge clk);cr=0;wait(cv);#1;
  if(overflow)$fatal(1,"compose unexpected overflow");
  for(n=0;n<6;n=n+1)begin error=$signed(cm[n*32+:32])-expected[n];if(error< -32 || error>32)$fatal(1,"compose coefficient %d actual %d expected %d",n,$signed(cm[n*32+:32]),expected[n]);end
  wait(cready);@(negedge clk);en=0;cr=1;@(negedge clk);cr=0;wait(cv);#1;if(cm!=m)$fatal(1,"OFF did not preserve supplied reference");
  $display("PASS pose calibrated angle/domain + source identity + ordered M*V + OFF");$finish;
 end
 initial begin #200000;$fatal(1,"timeout");end
endmodule
